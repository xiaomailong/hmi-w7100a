# Keil uVision project Loopback_UDP.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: hmi-w7100A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Drivers
    ./Drivers/: delay.c serial.c socket.c TCPIPCore.c wizmemcpy.c
  group src
    ./src/: lcd.c loopback.c main.c
